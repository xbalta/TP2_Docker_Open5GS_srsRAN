options:
  parameters:
    generate_options: qt_gui
    id: test_GNU
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '23040000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/user/Desktop/TP2_Docker_Open5GS_srsRAN/test_capture.txt
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/user/Desktop/TP2_Docker_Open5GS_srsRAN/test_capture_2.txt
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: udp://172.22.0.34:2001
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: udp://172.22.0.37:2000
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: udp://172.22.0.34:3001
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_pull_source_1
  id: zeromq_pull_source
  parameters:
    address: udp://172.22.0.37:3000
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://172.17.0.1:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://172.17.0.1:2001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://172.22.0.34:3001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://172.22.0.37:3000
    timeout: '100'
    type: complex
  states: {}

connections:
- [zeromq_pull_source_0, '0', blocks_file_sink_0, '0']
- [zeromq_pull_source_0, '0', qtgui_time_sink_x_0, '0']
- [zeromq_pull_source_0, '0', zeromq_pub_sink_1, '0']
- [zeromq_pull_source_1, '0', blocks_file_sink_0_0, '0']
- [zeromq_pull_source_1, '0', qtgui_time_sink_x_0, '1']
- [zeromq_pull_source_1, '0', zeromq_pub_sink_0, '0']
- [zeromq_req_source_0, '0', blocks_file_sink_0, '0']
- [zeromq_req_source_0, '0', qtgui_time_sink_x_0, '0']
- [zeromq_req_source_0, '0', zeromq_rep_sink_0, '0']
- [zeromq_req_source_1, '0', blocks_file_sink_0_0, '0']
- [zeromq_req_source_1, '0', qtgui_time_sink_x_0, '1']
- [zeromq_req_source_1, '0', zeromq_rep_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
